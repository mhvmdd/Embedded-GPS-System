# Keil uVision project Project.uvproj, settings and files
target TIVA C (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Project
  c flags: Optim=1
  c include: ..\Drivers\APP;..\Drivers\HAL;..\Drivers\LIB;..\Drivers\MCAL
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./: startup_TM4C123.s
  group APP
    ../Drivers/APP/: main.c Program.c
  group HAL
    ../Drivers/HAL/GPS/: GPS.c
    ../Drivers/HAL/LCD/: LCD.c
    ../Drivers/HAL/LED/: LED.c
    ../Drivers/HAL/SWITCH/: SWITCH.c
  group MCAL
    ../Drivers/MCAL/ADC/: ADC.c
    ../Drivers/MCAL/EEPROM/: EEPROM.c
    ../Drivers/MCAL/GPIO/: GPIO.c
    ../Drivers/MCAL/SYSTICK/: SYSTICK.c
    ../Drivers/MCAL/UART/: UART.c
